# Keil uVision project WIFI.uvprojx, settings and files
target LYG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LYG +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\gpio;..\..\User\SysTick;..\..\User\USART;..\..\User\Common;..\..\User\ESP8266;..\..\User\Send;..\..\User\DHT11;..\..\User\DS18B20;..\..\User\Sys;..\..\User\MQ-7;..\..\User\mod;..\..\User\delay;..\..\User\rtc;..\..\User\tim;..\..\User\SIM;..\..\User\SIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ReadMe
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Common/: Common.c
    ../../User/sys/: sys.c
    ../../User/SysTick/: SysTick.c
    ../../User/Send/: send.c
    ../../User/mod/: mod.c usart_mod.c
    ../../User/delay/: delay.c
    ../../User/rtc/: rtc.c
    ./: tim3.c 24cxx.c
    ../../User/iic/: iic.c
software components: CMSIS:CORE 5.1.1
